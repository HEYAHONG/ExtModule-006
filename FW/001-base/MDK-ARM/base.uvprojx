# Keil uVision project base.uvprojx, settings and files
target base (6240000::V6.24::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.2.2.7
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: base
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HBOX_CONFIG_HEADER=hbox_config.h
  c misc: -Wno-sign-compare -Wno-unused-variable -Wno-unused-parameter -Wno-char-subscripts -Wno-unused-but-set-variable
  c include: ..\;..\..\3rdparty\SWM341_Lib\master\SWM341_StdPeriph_Driver\CSL\SWM341_StdPeriph_Driver;..\..\3rdparty\SWM341_Lib\master\SWM341_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\3rdparty\SWM341_Lib\master\SWM341_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\3rdparty\HCppBox\master\hbox;..\..\3rdparty\HCppBox\master\hbox\cpp;..\FreeRTOS-Port
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../: main.cpp hbox_config.c sdram.cpp
  group CSL/StdPeriph
    ../../3rdparty/SWM341_Lib/master/SWM341_StdPeriph_Driver/CSL/SWM341_StdPeriph_Driver/: SWM341_adc.c SWM341_can.c SWM341_cordic.c SWM341_crc.c SWM341_dac.c SWM341_div.c SWM341_dma.c SWM341_dma2d.c SWM341_exti.c SWM341_flash.c SWM341_gpio.c SWM341_i2c.c SWM341_iofilt.c SWM341_jpeg.c SWM341_lcd.c SWM341_port.c SWM341_pwm.c SWM341_qei.c SWM341_rtc.c SWM341_sdio.c SWM341_sdram.c SWM341_sfc.c SWM341_sleep.c SWM341_spi.c SWM341_timr.c SWM341_uart.c SWM341_usbd.c SWM341_usbh.c SWM341_wdt.c
  group CSL/Startup
    ../../3rdparty/SWM341_Lib/master/SWM341_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM341.c
    ./: startup_SWM341.s syscalls.c
  group HBox
    ../../3rdparty/HCppBox/master/hbox/: h3rdparty.c hcompiler.c hcrypto.c hdefaults.c hdriverframework.c hevent.c hgui.c hlocale.c hmemory.c hnet.c hruntime.c hshell.c hsimulator.c huuid.c
  group HBox_cpp
    ../../3rdparty/HCppBox/master/hbox/cpp/: hchain.cpp hcpprt.cpp hfifo.cpp hloop.cpp hobj.cpp hsim.cpp hsim.mcs51.cpp hslots.cpp hsoftdog.cpp
  group HBox_3rdparty
    ../../3rdparty/HCppBox/master/hbox/h3rdparty/: h3rdparty_argtable3_arg_cmd.c h3rdparty_argtable3_arg_date.c h3rdparty_argtable3_arg_dbl.c h3rdparty_argtable3_arg_dstr.c h3rdparty_argtable3_arg_end.c h3rdparty_argtable3_arg_file.c h3rdparty_argtable3_arg_getopt_long.c h3rdparty_argtable3_arg_hashtable.c h3rdparty_argtable3_arg_int.c h3rdparty_argtable3_arg_lit.c h3rdparty_argtable3_arg_rem.c h3rdparty_argtable3_arg_rex.c h3rdparty_argtable3_arg_str.c h3rdparty_argtable3_arg_utils.c h3rdparty_argtable3_argtable3.c h3rdparty_cjson.c h3rdparty_cjson_port.c h3rdparty_cjsonutils.c h3rdparty_common.c h3rdparty_freebsd_elf_header.c h3rdparty_freertos_kernel_croutine.c h3rdparty_freertos_kernel_event_groups.c h3rdparty_freertos_kernel_heap.c h3rdparty_freertos_kernel_list.c h3rdparty_freertos_kernel_queue.c h3rdparty_freertos_kernel_stream_buffer.c h3rdparty_freertos_kernel_tasks.c h3rdparty_freertos_kernel_timers.c h3rdparty_libfdt_fdt.c h3rdparty_libfdt_fdt_addresses.c h3rdparty_libfdt_fdt_check.c h3rdparty_libfdt_fdt_empty_tree.c h3rdparty_libfdt_fdt_overlay.c h3rdparty_libfdt_fdt_ro.c h3rdparty_libfdt_fdt_rw.c h3rdparty_libfdt_fdt_strerror.c h3rdparty_libfdt_fdt_sw.c h3rdparty_libfdt_fdt_wip.c h3rdparty_libfdt_port.c h3rdparty_libqrencode_bitstream.c h3rdparty_libqrencode_mask.c h3rdparty_libqrencode_mmask.c h3rdparty_libqrencode_mqrspec.c h3rdparty_libqrencode_port.c h3rdparty_libqrencode_qrencode.c h3rdparty_libqrencode_qrinput.c h3rdparty_libqrencode_qrspec.c h3rdparty_libqrencode_rsecc.c h3rdparty_libqrencode_split.c h3rdparty_lz4_lz4.c h3rdparty_lz4_lz4file.c h3rdparty_lz4_lz4frame.c h3rdparty_lz4_lz4hc.c h3rdparty_lz4_port.c h3rdparty_lz4_xxhash.c h3rdparty_mini-rv32ima_port.c h3rdparty_mqtt_packet.c h3rdparty_pb_common.c h3rdparty_pb_decode.c h3rdparty_pb_encode.c h3rdparty_pb_port_msg_main_entry.c h3rdparty_printf.c h3rdparty_softfloat.c h3rdparty_softfp.c h3rdparty_tlsf_port.c h3rdparty_tlsf_tlsf.c h3rdparty_uriparser_UriCommon.c h3rdparty_uriparser_UriCompare.c h3rdparty_uriparser_UriCopy.c h3rdparty_uriparser_UriEscape.c h3rdparty_uriparser_UriFile.c h3rdparty_uriparser_UriIp4.c h3rdparty_uriparser_UriIp4Base.c h3rdparty_uriparser_UriMemory.c h3rdparty_uriparser_UriNormalize.c h3rdparty_uriparser_UriNormalizeBase.c h3rdparty_uriparser_UriParse.c h3rdparty_uriparser_UriParseBase.c h3rdparty_uriparser_UriQuery.c h3rdparty_uriparser_UriRecompose.c h3rdparty_uriparser_UriResolve.c h3rdparty_uriparser_UriSetFragment.c h3rdparty_uriparser_UriSetHostAuto.c h3rdparty_uriparser_UriSetHostCommon.c h3rdparty_uriparser_UriSetHostIp4.c h3rdparty_uriparser_UriSetHostIp6.c h3rdparty_uriparser_UriSetHostIpFuture.c h3rdparty_uriparser_UriSetHostRegName.c h3rdparty_uriparser_UriSetPath.c h3rdparty_uriparser_UriSetPort.c h3rdparty_uriparser_UriSetQuery.c h3rdparty_uriparser_UriSetScheme.c h3rdparty_uriparser_UriSetUserInfo.c h3rdparty_uriparser_UriShorten.c h3rdparty_uriparser_UriVersion.c h3rdparty_Z80_port.c h3rdparty_Z80_Z80.c h3rdparty_zlib_adler32.c h3rdparty_zlib_compress.c h3rdparty_zlib_crc32.c h3rdparty_zlib_deflate.c h3rdparty_zlib_gzclose.c h3rdparty_zlib_gzlib.c h3rdparty_zlib_gzread.c h3rdparty_zlib_gzwrite.c h3rdparty_zlib_infback.c h3rdparty_zlib_inffast.c h3rdparty_zlib_inflate.c h3rdparty_zlib_inftrees.c h3rdparty_zlib_port.c h3rdparty_zlib_trees.c h3rdparty_zlib_uncompr.c h3rdparty_zlib_zutil.c
  group FreeRTOS
    ../FreeRTOS-Port/: mpu_wrappers_v2_asm.c port.c portasm.c
